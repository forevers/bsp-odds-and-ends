IMAGE_INSTALL:append = " \
    ess-uio-mem-test \
    build-version \
    xilinx-bootbin \
"
