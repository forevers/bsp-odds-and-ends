# compile options to support pmu features
YAML_COMPILER_FLAGS:append = " -DENABLE_EM -DENABLE_SCHEDULER -DEFUSE_ACCESS"